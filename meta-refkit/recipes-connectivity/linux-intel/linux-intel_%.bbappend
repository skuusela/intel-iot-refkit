FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://nftables.cfg"
